# Keil uVision project GPIO_SwDebounce.uvproj, settings and files
target GPIO_SwDebounce (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC122SD2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: GPIO_SwDebounce
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC122\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC122.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC122/Source/ARM/: startup_NUC122.s
    ../../../../Library/Device/Nuvoton/NUC122/Source/: system_NUC122.c
  group User
    ../: main.c debounce.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c gpio.c sys.c uart.c
