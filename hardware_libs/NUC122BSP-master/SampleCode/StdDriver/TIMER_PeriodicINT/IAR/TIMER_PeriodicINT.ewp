# IAR project TIMER_PeriodicINT.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC122AN series Nuvoton NUC122AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC122\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_PeriodicINT.bin
  ILINK.IlinkOutputFile: TIMER_PeriodicINT.out
  ILINK.IlinkIcfFile: TIMER_PeriodicINT.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC122/Source/IAR/: startup_NUC122.s
    ../../../../Library/Device/Nuvoton/NUC122/Source/: system_NUC122.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
