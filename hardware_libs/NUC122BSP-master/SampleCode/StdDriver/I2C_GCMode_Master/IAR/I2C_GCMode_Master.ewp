# IAR project I2C_GCMode_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC122AN series Nuvoton NUC122AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC122\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_GCMode_Master.bin
  ILINK.IlinkOutputFile: I2C_GCMode_Master.out
  ILINK.IlinkIcfFile: I2C_GCMode_Master.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/NUC122/Source/IAR/: startup_NUC122.s
    ../../../../Library/Device/Nuvoton/NUC122/Source/: system_NUC122.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c
  group Source Files
    ../: main.c
